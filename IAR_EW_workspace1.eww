<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\IAR_EW_projects\IAR_EW_pr1.ewp</path>
    </project>
    <batchBuild />
</workspace>
