# IAR project IAR_EW_pr1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS; periphery; interfaces; Soft_SWD; devices; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_EW_pr1.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: IAR_EW_pr1.icf
  ILINK.IlinkExtraOptions: --image_input "firmwares\target_n32g455_ram.bin",target_firm_RAM,FIRMWARE_SECTION,4; --image_input "firmwares\target_n32g455_flash.bin",target_firm_FLASH,FIRMWARE_SECTION,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    devices/: 7_segment_indicator.c 7_segment_indicator.h AD9833.c AD9833.h BL24CM1A.c BL24CM1A.h FM25Q08B.c FM25Q08B.h
    ./: flash.c flash.h image_processing.c image_processing.h main.c ov2640.c ov2640.h
  group CMSIS
    CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h startup_stm32f407xx.s stm32f407xx.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group firmwares
    firmwares/: target_n32g455_flash.bin target_n32g455_ram.bin
  group interfaces
    interfaces/: dcmi.c dcmi.h i2c.c i2c.h spi.c spi.h usart.c usart.h
  group periphery
    periphery/: button.c button.h exti.c exti.h gpio.c gpio.h LED.c LED.h systick.c systick.h
  group Soft_SWD
    Soft_SWD/: N32G45x.c N32G45x_Flash.h programmer_target_Flash.c programmer_target_Flash.h soft_SWD.c soft_SWD.h
