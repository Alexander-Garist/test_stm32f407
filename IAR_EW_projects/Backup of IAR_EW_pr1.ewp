# IAR project Backup of IAR_EW_pr1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_EW_pr1.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h startup_stm32f407xx.s stm32f407xx.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group inc
    ./: BL24CM1A.h exti.h FM25Q08B.h gpio.h i2c.h spi.h systick.h
  group src
    ./: BL24CM1A.c exti.c FM25Q08B.c gpio.c i2c.c spi.c systick.c
